** sch_path: cace/templates/ota-5t-ac.sch
* Copyright 2024 Harald Pretl
**.subckt ota-5t-ac
Vdd v_dd GND CACE{vdd}
Vss v_ss GND 0
C1 v_out v_ss CACE{cload} m=1
Vin v_in v_ss dc CACE{vin} ac 1
I0 v_dd net1 CACE{ibias}
Venable v_ena v_ss 1.5
.save v(v_in)
.save v(v_out)
.save v(v_ena)
xota v_dd v_out v_in v_out net1 v_ena v_ss ota-5t
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

.control
set num_threads=1

op
let dcgain=v(v_out)/v(v_in)

ac dec 101 10 100MEG
meas ac acgain MAX vmag(v_out) FROM=10 TO=100
let f3db = acgain/sqrt(2)
meas ac fbw WHEN vmag(v_out)=f3db FALL=1

echo $&op1.dcgain $&fbw > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.lib cornerMOSlv.lib mos_CACE{corner}
.lib cornerMOShv.lib mos_CACE{corner}

**** end user architecture code
**.ends
.GLOBAL GND
.end
