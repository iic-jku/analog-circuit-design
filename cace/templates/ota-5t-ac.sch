** sch_path: cace/templates/ota-5t-ac.sch
* Copyright 2024 Harald Pretl
**.subckt ota-5t-ac
Vdd v_dd GND CACE{vdd}
Vss v_ss GND 0
C1 v_out v_ss CACE{cload} m=1
Vin v_in v_ss dc CACE{vin} ac 1
I0 v_dd net1 CACE{ibias}
Venable v_ena v_ss 1.5
.save v(v_in)
.save v(v_out)
.save v(v_ena)
x1 v_dd v_out v_in v_out net1 v_ena v_ss ota-5t
**** begin user architecture code


.lib cornerMOSlv.lib mos_CACE{corner}
.include CACE{DUT_path}
.temp CACE{temperature}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

.control
op
ac dec 101 1k 100MEG

meas ac dcgain MAX vmag(v_out) FROM=10 TO=10k
let f3db = dcgain/sqrt(2)
meas ac fbw WHEN vmag(v_out)=f3db FALL=1

echo $&dcgain $&fbw > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends

* expanding   symbol:  /foss/designs/xschem/ota-5t.sym # of pins=7
** sym_path: xschem/ota-5t.sym
** sch_path: xschem/ota-5t.sch
.subckt ota-5t vdd vout vinp vinn ibias_20u d_ena vss
*.ipin ibias_20u
*.iopin vdd
*.iopin vss
*.ipin vinp
*.ipin vinn
*.opin vout
*.ipin d_ena
XM5 vss gate_n tail vss sg13_lv_nmos w=0.5u l=5u ng=1 m=1 mm_ok=1
XM4 vout gate_p vdd vdd sg13_lv_pmos w=1.5u l=5u ng=1 m=1 mm_ok=1
XM1 tail vinp gate_p vss sg13_lv_nmos w=2u l=5u ng=1 m=1 mm_ok=1
XM2 tail vinn vout vss sg13_lv_nmos w=2u l=5u ng=1 m=1 mm_ok=1
XM3 gate_p gate_p vdd vdd sg13_lv_pmos w=1.5u l=5u ng=1 m=1 mm_ok=1
XM6 vss gate_n ibias_20u vss sg13_lv_nmos w=2.5u l=5u ng=5 m=1 mm_ok=1
XM9 vss ena_n gate_n vss sg13_lv_nmos w=0.5u l=0.13u ng=1 m=1 mm_ok=1
XM11 gate_p d_ena vdd vdd sg13_lv_pmos w=1.5u l=0.13u ng=1 m=1 mm_ok=1
XM7 vss d_ena ena_n vss sg13_lv_nmos w=0.5u l=0.13u ng=1 m=1 mm_ok=1
XM8 ena_n d_ena vdd vdd sg13_lv_pmos w=1.5u l=0.13u ng=1 m=1 mm_ok=1
XM10 gate_n d_ena ibias_20u vss sg13_lv_nmos w=0.5u l=0.13u ng=1 m=1 mm_ok=1
.ends

.GLOBAL GND
.end
