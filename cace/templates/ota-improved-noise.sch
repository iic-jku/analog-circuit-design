** sch_path: cace/templates/ota-improved-noise.sch
* Copyright 2024 Harald Pretl
**.subckt ota-improved-noise
Vdd v_dd GND CACE{vdd}
Vss v_ss GND 0
C1 v_out v_ss CACE{cload} m=1
Vin v_in v_ss dc CACE{vin} ac 1
I0 v_dd net1 CACE{ibias}
Venable v_ena v_ss 1.5
.save v(v_in)
.save v(v_out)
.save v(v_ena)
xota v_dd v_out v_in v_out net1 v_ena v_ss ota-improved
**** begin user architecture code


.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_res}
.include CACE{DUT_path}
.temp CACE{temp}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]
.option sparse

.control
set num_threads=1
save all
noise v(v_out) Vin dec 101 1k 100MEG

let noise=onoise_total
echo $&noise > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
