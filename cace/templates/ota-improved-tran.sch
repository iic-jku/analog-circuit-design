** sch_path: cace/templates/ota-improved-tran.sch
* Copyright 2024 Harald Pretl
**.subckt ota-improved-tran
Vdd v_dd GND CACE{vdd}
Vss v_ss GND 0
C1 v_out v_ss CACE{cload} m=1
Vin v_in v_ss CACE{vin}
I0 v_dd net1 dc 0 pwl(0 0 1.1u 0 1.2u CACE{ibias})
Venable v_ena v_ss dc 0 pwl(0 0 1u 0 1.1u CACE{vdd})
.save v(v_in)
.save v(v_out)
.save v(v_ena)
x1 v_dd v_out v_in v_out net1 v_ena v_ss ota-5t
**** begin user architecture code


.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_res}
.include CACE{DUT_path}
.temp CACE{temp}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]
.ic v(v_vout)=0

.control
set num_threads=1
tran 0.005u 15u uic

let vout_limit=CACE{vin}*0.99
meas tran tcross WHEN v(v_out)=vout_limit
let vena_limit=0.5*CACE{vdd}
meas tran tstart WHEN v(v_ena)=vena_limit
let tsettle=tcross-tstart

echo $&tsettle > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
